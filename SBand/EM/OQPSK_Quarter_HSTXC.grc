options:
  parameters:
    generate_options: qt_gui
    id: OQPSK_Quarter_HSTXC
    output_language: python
    title: '[EX3-CM] S Band Receiver'
  states: {}

blocks:
- name: agc
  id: variable_qtgui_check_box
  parameters:
    comment: USRP AGC Toggle
    'false': Disabled
    gui_hint: settings@0:1,0,1,1
    label: AGC
    'true': Enabled
    type: string
    value: Disabled
  states: {}
- name: antenna
  id: variable_qtgui_chooser
  parameters:
    comment: Antenna selector
    gui_hint: settings@0:0,0,1,1
    label: USRP Antenna Connection
    label0: RX2
    label1: TRX
    num_opts: '2'
    option0: RX2
    option1: TRX
    type: string
    value: RX2
    widget: radio_buttons
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: center_freq
    start: '-50000'
    step: '50'
    stop: '50000'
    value: '0'
  states: {}
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: '80'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79, 109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {state: disabled}
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[83,113]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_rec
  id: variable
  parameters:
    comment: |-
      Combines the values of the global recording toggle
      and the decoded data recording checkbox
    value: qt_dec_rec_toggle and record_toggle
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2200000000'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    comment: RF receive center frequency
    gui_hint: settings@0:10,0,1,10
    label: Receive Frequency
    start: '2200000000'
    step: '100000'
    stop: '2300000000'
    value: '2200000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: USRP absolute gain setting
    gui_hint: settings@0:1,1,1,9
    label: Manual Gain (dB)
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    label: loop_bw
    start: '0.0005'
    step: '0.0005'
    stop: '1'
    value: '0.01'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: null_path
  id: variable
  parameters:
    value: '"NUL:" if platform == "nt" else "/dev/null"'
  states: {}
- name: platform
  id: variable
  parameters:
    value: name
  states: {}
- name: qpsk_const
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707-0.707j, 0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: qt_dec_rec_toggle
  id: variable_qtgui_check_box
  parameters:
    comment: Enables recording of decoded data when "record" is pressed
    'false': 'False'
    gui_hint: settings@1:4,0,1,1
    label: Decoded data recording
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: qt_raw_rec_toggle
  id: variable_qtgui_check_box
  parameters:
    comment: Enables recording of raw data when "record" is pressed
    'false': 'False'
    gui_hint: settings@1:3,0,1,1
    label: Raw data recording
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: raw_rec
  id: variable
  parameters:
    comment: |-
      Combines the values of the global recording toggle
      and the raw data recording checkbox
    value: qt_raw_rec_toggle and record_toggle
  states: {}
- name: rec_note
  id: variable_qtgui_entry
  parameters:
    comment: Comment to be included in the filename
    gui_hint: settings@1:1,0,1,1
    label: '"Recording Note"'
    type: string
    value: '"recording"'
  states: {}
- name: record_toggle
  id: variable_qtgui_toggle_button_msg
  parameters:
    comment: Toggle button to activate recording
    gui_hint: 0,0,1,1
    initPressed: 'False'
    label: Record
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: recording_path
  id: variable_qtgui_entry
  parameters:
    comment: |-
      GUI entry for recording storage location
      Defaults to ./rec/
    gui_hint: settings@1:0,0,1,1
    label: '"Recording Location"'
    type: string
    value: f"{Path.cwd()}\\rec\\"
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts,1/float(4),0.35,11*4*nfilts)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '40000000'
  states: {}
- name: timestamp
  id: variable
  parameters:
    value: str(datetime.fromtimestamp(time.time()).strftime("%Y-%m-%dT%H.%M.%S"))
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:0,0
    samp_rate: samp_rate
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Sink for raw data to be recorded to a file
      Path is determined by the recording_path QT GUI Entry
      File name is determined using the timestamp when record is pressed and the current RF parameters
      Data is sent to NUL: or /dev/null when recording is not active
    file: (recording_path)+(str(datetime.fromtimestamp(time.time()).strftime("%Y-%m-%dT%H.%M.%S")))+"_"+rec_note+"_"+str(frequency/1000000)+"MHz_"+str(samp_rate/1000000)+"Msps_RAW.bin" if raw_rec else null_path
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Sink for decoded data to be recorded to a file
      Path is determined by the recording_path QT GUI Entry
      File name is determined using the timestamp when record is pressed and the current RF parameters
      Data is sent to NUL: or /dev/null when recording is not active
    file: recording_path+str(datetime.fromtimestamp(time.time()).strftime("%Y-%m-%dT%H.%M.%S"))+rec_note+"_DECODED.bin" if dec_rec else null_path
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/albertasat/ex3_sdr/ex3_sdr/SBand/EM/test.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/sam/Downloads/hstxc_2mbit_oqpsk_noscram_testmode_4msamp.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_const
  states: {}
- name: digital_costas_loop_cc_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.01'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 2, 3]'
  states: {}
- name: digital_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    sps: samp_per_sym
    taps: rrc_taps
    type: ccf
  states: {}
- name: fec_extended_decoder_0_0_1
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_cc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1.0, samp_rate, -6000000, 6000000, transition_bw)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import time
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from pathlib import Path
  states: {}
- name: import_1_0_0
  id: import
  parameters:
    imports: from pathlib import Path
  states: {}
- name: import_1_1
  id: import
  parameters:
    imports: from os import name
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Primary frequency domain visualization
    fc: frequency
    fftsize: '1024'
    gui_hint: 0,6,5,5
    legend: 'False'
    name: Frequency
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate * 2
    comment: Primary frequency domain visualization
    fc: frequency
    fftsize: '1024'
    legend: 'False'
    name: Frequency
    type: complex
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    comment: Recording Indicator
    gui_hint: 1,0,1,1
    label: ''
    offColor: black
    onColor: red
    position: '2'
    state: record_toggle
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 5,1,5,10
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Primary time domain visualization
    fc: frequency
    fftsize: '1024'
    gui_hint: 5,1,5,10
    name: Waterfall
    type: float
  states: {state: disabled}
- name: satellites_descrambler308_0
  id: satellites_descrambler308
  parameters: {}
  states: {}
- name: satellites_rms_agc_0_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1'
  states: {state: bypassed}
- name: settings
  id: qtgui_tab_widget
  parameters:
    comment: Settings menus at the bottom of the window
    gui_hint: 20,0,1,11
    label0: RF Settings
    label1: Recording Settings
    num_tabs: '2'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: antenna
    bw0: '40000000'
    center_freq0: frequency
    dc_offs_enb0: auto
    dev_args: type=b200
    gain0: gain
    rx_agc0: agc
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0, '0', fec_extended_decoder_0_0_1, '0']
- [blocks_char_to_float_1, '0', qtgui_number_sink_0, '0']
- [blocks_char_to_float_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_map_bb_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_costas_loop_cc_1, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [digital_diff_decoder_bb_0, '0', satellites_descrambler308_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_1, '0', blocks_char_to_float_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [fec_extended_decoder_0_0_1, '0', digital_diff_decoder_bb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', digital_costas_loop_cc_1, '0']
- [record_toggle, state, qtgui_ledindicator_0, state]
- [satellites_descrambler308_0, '0', blocks_char_to_float_1, '0']
- [satellites_descrambler308_0, '0', blocks_pack_k_bits_bb_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_float_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', satellites_rms_agc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
