options:
  parameters:
    generate_options: qt_gui
    id: SBand_full_rate_conv_encode_OQPSK
    output_language: python
    title: S-Band full rate OQPSK scrambling convolutional encoding
  states: {}

blocks:
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[83,113]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2200000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '40000000'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Files\RawData
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: Files\ProcessedOutput
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: digital.constellation_qpsk().base()
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.02'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 2, 3]'
  states: {}
- name: digital_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: 20m
    max_dev: '1.5'
    osps: '4'
    sps: '4'
    taps: firdes.root_raised_cosine(1.0, 8, 1.0, 0.35, 44)
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class intelsat_descrambler(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self):  # only default arguments here
              """arguments to this function how up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Intelsat Descrambler',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
       
              self.LFSR = int(0xfffff)
              self.synchronousCount = 0

          def work(self, input_items, output_items):
              input_bits = input_items[0]
              out = output_items[0]

              for i in range(len(input_bits)):
                  bit = int(input_bits[i]) & 1
                  tap1 = self.LFSR & 1
                  tap3 = (self.LFSR >> 2) & 1
                  tap9 = (self.LFSR >> 8) & 1
                  tap20 = (self.LFSR >> 19) & 1

                  xnor1 = int(not (tap3 ^ tap20))
                  xnor2 = int(not (xnor1 ^ int(self.synchronousCount == 0b11111)))
                  xnor3 = int(not (xnor2 ^ bit))

                  if not (tap1 ^ tap9):
                      self.synchronousCount = (self.synchronousCount + 1) & 0b11111
                  else:
                      self.synchronousCount = 0

                  self.LFSR = ((self.LFSR << 1) | bit) & 0xfffff
                  out[i] = xnor3  # write each descrambled bit

              return len(input_bits)  # inform scheduler you handled this many items
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_cc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1.0, samp_rate, -6000000, 6000000, transition_bw)
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: byte
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: byte
  states: {state: disabled}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '6000000'
    center_freq0: freq
    dev_args: '""'
    gain0: '40'
    iq_imbal_enb0: auto
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0, '0', fec_extended_decoder_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_map_bb_1, '0']
- [digital_constellation_decoder_cb_1, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_1, '0', blocks_char_to_float_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, '0', blocks_file_sink_1, '0']
- [epy_block_0, '0', qtgui_number_sink_1, '0']
- [fec_extended_decoder_0, '0', epy_block_0, '0']
- [fec_extended_decoder_0, '0', qtgui_number_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [uhd_usrp_source_1, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
