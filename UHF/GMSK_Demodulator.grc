options:
  parameters:
    generate_options: qt_gui
    id: GMSK_Demodulator
    output_language: python
    title: GMSK Text Demodulator
  states: {}

blocks:
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: demodulated_text.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: raw_bytes.txt
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: demodulated_text.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: ax25_hamlet.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5'
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    comment: AX.25 transmits the LSB of each byte first, so unpack each byte from the test file in a way that it "transmits" the LSB first
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    do_unpack: 'False'
    samples_per_symbol: '8'
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    comment: |-
      Each frame from the UTRX-A will have a total of 16 bytes in the header.
      The maximum size will be 16 header bytes + 256 payload bytes + 2 CRC bytes
    max: '274'
    min: '16'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, trim_len=16):
              gr.sync_block.__init__(self, name='trim_pdu', in_sig=None, out_sig=None)
              self.trim_len = trim_len
              self.message_port_register_in(pmt.intern('in'))
              self.message_port_register_out(pmt.intern('out'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              data = pmt.cdr(msg)
              vec = pmt.u8vector_elements(data)
              trimmed = vec[self.trim_len:]
              new_vec = pmt.init_u8vector(len(trimmed), trimmed)
              self.message_port_pub(pmt.intern('out'), pmt.cons(meta, new_vec))
    comment: |-
      Trim the header bytes  (first 16) off of each packet since we only want the payload data.
      The two CRC bytes at the end get discarded by the previous funciton.
    trim_len: '16'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Quadrature Demod
    size: '256'
    srate: samp_rate
    type: float
    ylabel: Frequency
    yunit: Hz
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: Synced Samples
    size: '32'
    srate: samp_rate/8
    type: float
    ylabel: Frequency
    yunit: Hz
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_gmsk_mod_0, '0']
- [blocks_throttle2_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_hdlc_deframer_bp_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_hdlc_deframer_bp_0, out, epy_block_0, in]
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [epy_block_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
